<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM322xG_EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx\startup\iar\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>STM32_EVAL</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\stm32_eval.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Utilities\STM32_EVAL\Common\stm32_eval_sdio_sd.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>jtag</name>
      <file>
        <name>$PROJ_DIR$\..\jtag\lenval.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\jtag\micro.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\jtag\ports.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\gpio_low_level.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\stm_host.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user_timer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\user_uart.c</name>
    </file>
  </group>
</project>


