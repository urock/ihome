<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>STM322xG_EVAL</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>CMSIS</name>
    <file>
      <name>$PROJ_DIR$\..\src\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>EWARM</name>
    <file>
      <name>$PROJ_DIR$\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>FreeRTOS</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\croutine.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\list.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\queue.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\tasks.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\timers.c</name>
    </file>
  </group>
  <group>
    <name>LwIP</name>
    <group>
      <name>Api</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\api_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\api_msg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\err.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\netbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\netdb.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\netifapi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\sockets.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\api\tcpip.c</name>
      </file>
    </group>
    <group>
      <name>Core</name>
      <group>
        <name>IPv4</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\autoip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\icmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\igmp.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\inet.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\inet_chksum.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\ip.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\ip_addr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\ipv4\ip_frag.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\dhcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\dns.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\memp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\netif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\pbuf.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\raw.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\stats.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\sys.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\tcp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\tcp_in.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\tcp_out.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\core\udp.c</name>
      </file>
    </group>
    <group>
      <name>Netif</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\netif\etharp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\ethernetif.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\sys_arch.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>STM32F2x7_ETH_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2x7_ETH_Driver\src\stm32f2x7_eth.c</name>
    </file>
  </group>
  <group>
    <name>STM32F2xx_StdPeriph_Driver</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
  </group>
  <group>
    <name>User</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\inc\dmx512.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\FreeRTOSConfig.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\gpio_low_level.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\lwipopts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\main.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\netconf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\onewire.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\power_cntrl_thread.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\spi_low_level.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm32f2x7_eth_bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm32f2x7_eth_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm32f2xx_conf.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\stm32f2xx_it.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\sys_include.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\tcp_client_netconn.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\tcp_protocol.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\tcp_server_netconn.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\uart_low_level.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\uart_thread.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\inc\udp_server.h</name>
      </file>
    </group>
    <group>
      <name>portable</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\portable\MemMang\heap_2.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\portable\IAR\ARM_CM3\port.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\portable\IAR\ARM_CM3\portasm.s</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\src\dmx512.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\gpio_low_level.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\main.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\netconf.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\onewire.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\power_cntrl_thread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\spi_low_level.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stm32f2x7_eth_bsp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\tcp_client_netconn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\tcp_server_netconn.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\uart_low_level.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\uart_thread.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\src\udp_server.c</name>
    </file>
  </group>
</project>


