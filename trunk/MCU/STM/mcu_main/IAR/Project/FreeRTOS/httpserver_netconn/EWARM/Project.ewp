# IAR project Project.ewp, settings and files
configuration STM322xG_EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F207VG ST STM32F207VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F2XX; USE_STM322xG_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F2xx; ..\..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Libraries\STM32F2x7_ETH_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM322xG_EVAL; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\lwip; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\netif; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\src\include\ipv4; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7; ..\..\..\..\Utilities\Third_Party\lwip_v1.3.2\port\STM32F2x7\FreeRTOS\; ..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\portable\IAR\ARM_CM3\; ..\..\..\..\Utilities\Third_Party\FreeRTOS_v7.4.2\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\inc
  OBJCOPY.OOCOutputFile: mcu_main_01.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: stm32f2xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../src/: system_stm32f2xx.c
  group EWARM
    ./: startup_stm32f2xx.s
  group FreeRTOS
    ../../../../Utilities/Third_Party/FreeRTOS_v7.4.2/: croutine.c list.c queue.c tasks.c timers.c
  group LwIP/Api
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/Core
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/: dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
  group LwIP/Core/IPv4
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
  group LwIP/Netif
    ../../../../Utilities/Third_Party/lwip_v1.3.2/src/netif/: etharp.c
    ../../../../Utilities/Third_Party/lwip_v1.3.2/port/STM32F2x7/FreeRTOS/: ethernetif.c sys_arch.c
  group STM32F2x7_ETH_Driver
    ../../../../Libraries/STM32F2x7_ETH_Driver/src/: stm32f2x7_eth.c
  group STM32F2xx_StdPeriph_Driver
    ../../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_gpio.c stm32f2xx_rcc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c
  group User
    ../src/: dmx512.c flash.c gpio_low_level.c main.c netconf.c onewire.c power_cntrl_thread.c spi_low_level.c stm32f2x7_eth_bsp.c stm32f2xx_it.c tcp_client_netconn.c tcp_server_netconn.c uart_low_level.c uart_thread.c udp_server.c
  group User/inc
    ../inc/: dmx512.h flash.h FreeRTOSConfig.h gpio_low_level.h lwipopts.h main.h netconf.h onewire.h power_cntrl_thread.h spi_low_level.h stm32f2x7_eth_bsp.h stm32f2x7_eth_conf.h stm32f2xx_conf.h stm32f2xx_it.h sys_include.h tcp_client_netconn.h tcp_protocol.h tcp_server_netconn.h uart_low_level.h uart_thread.h udp_server.h
  group User/portable
    ../../../../Utilities/Third_Party/FreeRTOS_v7.4.2/portable/MemMang/: heap_2.c
    ../../../../Utilities/Third_Party/FreeRTOS_v7.4.2/portable/IAR/ARM_CM3/: port.c portasm.s
